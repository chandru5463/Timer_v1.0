<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\Timer_v1_0.ewp</path>
    </project>
    <batchBuild />
</workspace>